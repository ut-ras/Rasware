# Keil uVision project NavLib.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: NavLib (library)
  c flags: Optim=1
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group source
    ./: Startup.s
    ./src/: luddef.c
